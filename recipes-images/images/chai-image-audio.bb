inherit chai-image

IMAGE_INSTALL:append = " \
    alsa-utils \
"
