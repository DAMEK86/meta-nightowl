inherit chai-image-tiny

IMAGE_INSTALL_append = " \
    ser2net \
"